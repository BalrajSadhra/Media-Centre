# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c Thread.c Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c KBD.c KBD.h adcuser.c adcuser.h audio.h core_cm3.c core_cm3.h type.h usb.h usbaudio.h usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbdmain.c usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h usbdmain.h corgi2.c glass.c bffr.c minesweeper3.c minesweeper3.h LED.c LED.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:A/D Converter 1.0.0, Board Support:D/A Converter 1.0.0, USB:CORE 6.14.1, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
